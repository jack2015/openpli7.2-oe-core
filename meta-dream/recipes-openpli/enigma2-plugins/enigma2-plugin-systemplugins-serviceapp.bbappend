RRECOMMENDS_${PN}_dm800 = "gstplayer"
RRECOMMENDS_${PN}_dm800se = "gstplayer"
