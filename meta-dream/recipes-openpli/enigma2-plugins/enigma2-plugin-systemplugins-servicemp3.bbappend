SRC_URI = "git://github.com/jack2015/servicemp3.git;branch=master"
