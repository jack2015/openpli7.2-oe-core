DEPENDS_remove = "enigma2-plugin-softcams-rqcamd"
DEPENDS_remove = "enigma2-plugin-softcams-oscam"
DEPENDS_remove = "enigma2-plugin-softcams-oscam-emu"


