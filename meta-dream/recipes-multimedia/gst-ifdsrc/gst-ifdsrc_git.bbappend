SRC_URI = "git://github.com/jack2015/gst-ifdsrc.git"
