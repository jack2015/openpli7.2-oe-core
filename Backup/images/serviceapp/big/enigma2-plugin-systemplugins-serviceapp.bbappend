RRECOMMENDS_${PN}_dm800 = "gstplayer exteplayer3"
RRECOMMENDS_${PN}_dm800se = "gstplayer exteplayer3"
