RRECOMMENDS_${PN}_dm800se = "exteplayer3"
RRECOMMENDS_${PN}_dm800 = "exteplayer3"
SRC_URI = "git://github.com/jack2015/serviceapp.git;branch=develop"
